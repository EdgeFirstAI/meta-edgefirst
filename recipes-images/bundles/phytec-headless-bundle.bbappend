require recipes-images/bundles/edgefirst-rauc-signing.inc
