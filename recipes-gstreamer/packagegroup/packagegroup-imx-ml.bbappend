# Add Kinara Ara-2 NPU nnstreamer sub-plugin to ML packagegroup
ML_NNSTREAMER_PKGS:mx8mp-nxp-bsp:append = " nnstreamer-ara2"
ML_NNSTREAMER_PKGS:mx9-nxp-bsp:append = " nnstreamer-ara2"
